# Keil uVision project IOT_WASHER.uvprojx, settings and files
target IOT_BEEP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IOT_BEEP +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\Gizwits;..\HARDWARE\LED;..\HARDWARE\BEEP;..\WORK_MODE\DRY;..\WORK_MODE\WASHER;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\RELAY;..\HARDWARE\SHT2X;..\HARDWARE\TIM4;..\HARDWARE\USART_TO_LCD;..\HARDWARE\TIM5;..\HARDWARE\VOICE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/RELAY/: RELAY.C
    ../HARDWARE/SHT2X/: SHT2x.c
    ../HARDWARE/TIM4/: TIM4.c
    ../HARDWARE/TIM5/: TIM5.c
    ../HARDWARE/USART_TO_LCD/: USART_TO_LCD.c
    ../HARDWARE/VOICE/: VOICE.C
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group WorkMode
    ../WORK_MODE/DRY/: DRY.C
    ../WORK_MODE/WASHER/: WASHER.C
